## drivers/input/touchscreen/FT5X46/Kconfig
```kconfig
config TOUCHSCREEN_FT5X46
	bool "for FT5X46 driver"
	depends on I2C
	---help---
	say Y to enable driver for Touchpanel Focal FT5X46
```
